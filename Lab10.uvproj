# Keil uVision project Lab10.uvproj, settings and files
target Lab10 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: Blynk
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c misc: --C99
  c include: ..;..\..\..;.\Include;.\Library
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Library
    ./Library/: esp8266.c PLL.c PortF.c ST7735.c startup.s Timer2.c Timer3.c UART.c IO.s LCD.s
  group Source
    ./Library/: Blynk.c
    ./Source/: Buttons.c Debug.c Graphics.c Timer.c VirtualPins.c Lab10_Main.c PWM.c Tachometer.c Motor.c PID.c
  group Include
    ./Include/: Buttons.h Debug.h Graphics.h Timer.h VirtualPins.h esp8266.h PLL.h PortF.h ST7735.h Timer2.h Timer3.h tm4c123gh6pm.h UART.h Blynk.h PWM.h Tachometer.h Motor.h PID.h
